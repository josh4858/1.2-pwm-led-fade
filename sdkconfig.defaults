## sdkconfig.defaults
```kconfig
# Default ESP-IDF configuration for 1-2-pwm-led-fade
CONFIG_ESP32_DEFAULT_CPU_FREQ_160=y
```
